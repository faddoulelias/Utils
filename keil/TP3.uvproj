# Keil uVision project TP3.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: STM32F072RB STMicroelectronics
  cpu: IRAM(0x20000000-0x20003FFF) IROM(0x08000000-0x0801FFFF) CLOCK(8000000) CPUTYPE("Cortex-M0")
  output: TP3
  c flags: Optim=1
  c include: ..\app;..\drivers
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x4000
  group Keil
    ./: startup_stm32f072.s
  group System
    ../system/: system_stm32f0xx_HSI_RC_48MHz.c
  group App
    ../app/: main.c printf-stdarg.c
  group Drivers
    ../drivers/: bsp.c delay.c
